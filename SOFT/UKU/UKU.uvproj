# Keil uVision project UKU.uvproj, settings and files
target UKU(COM4) (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: UKU +hex
  c flags: Optim=4
  c define: UKU320_F,REVISION_C
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group HTTP
    E:/Users/Pal/DEVICES/UKU217_dev/SOFT/UKU/WEB/: web.inp
  group Startup
    ./: startup_LPC17xx.s Net_Config_HTTP.c
  group Source
    ./: common_func.c control.c mess.c ret.c gran.c avar_hndl.c eeprom_map.c cmd.h main.c simbols.c graphic.c snmp_data_file.c SNMP_MIB.c curr_version.c
  group System
    ./: memo.c system_LPC17xx.c Timer.c
  group Target
    ./: beep.c ad7705.c lcd_AGM1232_uku207_3.c 25lc640.c
    ./WEB/: Web.c
  group Connecting
    ./: full_can.c uart0.c modbus.c uart2.c bat_driver.c mcp2515.c sacred_sun.c sc16is7xx.c ztt.c MODBUS_TCP.c
  group Library
    C:/Keil/ARM/Boards/Keil/MCB1700/RL/TCPnet/Library/: EMAC_LPC17xx.c
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib
target UKU(COM3) (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU +hex
  c flags: Optim=3
  c define: UKU320_F,REVISION_C
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target UKU(COM5) (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU +hex
  c flags: Optim=3
  c define: UKU320_F,REVISION_C
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target UKU-MGTS(COM3) (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU +hex
  c flags: Optim=3
  c define: UKU_MGTS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target UKU-3U(COM3) (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU_3U +hex
  c flags: Optim=3
  c define: UKU_3U
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target UKU-ROSTELEKOM (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU +hex
  c flags: Optim=3
  c define: UKU_RSTKM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target UKU_GLONASS (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU_GL +hex
  c flags: Optim=3
  c define: UKU_GLONASS, UKU2071x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target UKU-KONTUR (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU_KONTUR +hex
  c flags: Optim=3
  c define: UKU_KONTUR
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target UKU-6U (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: UKU_6U +hex
  c flags: Optim=4
  c define: UKU_6U
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target UKU-220 (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU_220 +hex
  c flags: Optim=2
  c define: UKU_220
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target UKU-WOCAN (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU_6U_WOCAN +hex
  c flags: Optim=4
  c define: UKU_6U
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target UKU-6U-CAN (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU_6U_MIKRAN_CAN +hex
  c flags: Optim=4
  c define: UKU_6U,  _MIKRAN_CAN_, _CAN_DEBUG_
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target UKU-220-IPS-TERMOKOMPENSAT (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: UKU_220_IPS_TERMOKOMPENSAT +hex
  c flags: Optim=2
  c define: UKU_220_IPS_TERMOKOMPENSAT, UKU2071x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target UKU-220V2 (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU_220_v2 +hex
  c flags: Optim=4
  c define: UKU_220_V2, UKU2071x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target UKU-KONTUR2015 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: UKU_6U +hex
  c flags: Optim=4
  c define: UKU_KONTUR_2015
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target UKU-TELECORE2015 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: UKU_TELECORE2015 +hex
  c flags: Optim=4
  c define: UKU_TELECORE2015, TELECORE
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target UKU-6U-GLADKOV (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: UKU_6U_GLADKOV +hex
  c flags: Optim=4
  c define: UKU_6U, GLADKOV
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target UKU-TELECORE2016 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: UKU_TELECORE2016 +hex
  c flags: Optim=4
  c define: UKU_TELECORE2016, TELECORE, UKU2071x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target UKU-TELECORE2017 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: UKU_TELECORE2017 +hex
  c flags: Optim=4
  c define: UKU_TELECORE2017, TELECORE, UKU2071x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target VD (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: UKU_VD +hex
  BeforeMake: python curr_version.py
  c flags: Optim=2
  c define: UKU_VD, UKU_220_IPS_TERMOKOMPENSAT, UKU2071x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
